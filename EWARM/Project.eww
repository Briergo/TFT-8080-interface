<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TFT 8080 interface.ewp</path>
  </project>
  <batchBuild />
</workspace>
